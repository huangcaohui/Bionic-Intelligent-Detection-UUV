# Keil uVision project UUV.uvprojx, settings and files
target UUV (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: UUV +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\inc;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LED;..\HARDWARE\DS18B20;..\HARDWARE\GPS;..\HARDWARE\MOTOR;..\HARDWARE\UltrasonicWave;..\SYSTEM\inc;..\USERLIB\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/GPS/: gps.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/UltrasonicWave/: UltrasonicWave.c
  group SYSTEM
    ../SYSTEM/src/: sys.c delay.c pwm.c timer.c usart2.c usart3.c uart4.c dma1.c adc.c iwdg.c
  group USERLIB
    ../USERLIB/src/: host_computer.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_adc.c misc.c stm32f10x_iwdg.c
  group README
    ../: README.TXT
